SRC_URI_append = " file://sdboot_mod.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/files"
